# Keil uVision project LoraSTMacH7.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32H743VITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.4.1.3
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00100000) IROM2(0x08100000,0x00100000) XRAM(0x30000000,0x00048000) XRAM2(0x38000000,0x00010000) CPUTYPE("Cortex-M7") FPU3(DFPU) DSP CLOCK(12000000) ELITTLE
  output: LoraSTMacH7_Ra02 +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,REGION_CN470
  c misc: --C99 --split_sections
  c include: .\fwlib\CMSIS\Include;.\fwlib\CMSIS\Device\ST\STM32H7xx\Include;.\fwlib\STM32H7xx_HAL_Driver\Inc;.\apps;.\apps\common;.\mac;.\mac\region;.\peripherals;.\peripherals\soft-se;.\boards;.\radio;.\radio\sx1276;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT5: ROM 0x8100000 size 0x100000
  memory RVCT6: RAM 0x30000000 size 0x48000
  memory RVCT7: RAM 0x38000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  link misc: --diag_suppress=L6329
  group start_up
    ./: startup_stm32h743xx.s
  group apps
    ./apps/: main.c system_stm32h7xx.c stm32h7xx_it.c
    ./apps/common/: NvmCtxMgmt.c
  group mac
    ./mac/region/: Region.c RegionCommon.c RegionCN470.c
    ./mac/: LoRaMac.c LoRaMacAdr.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c LoRaMacClassB.c
  group peripherals
    ./peripherals/soft-se/: aes.c cmac.c soft-se.c
  group boards
    ./boards/: board.c led-board.c gpio-board.c uart-board.c spi-board.c lpm-board.c rtc-board.c utilities.c delay-board.c sx1276-board.c
  group radio
    ./radio/sx1276/: sx1276.c
  group system
    ./system/: gpio.c fifo.c uart.c delay.c systime.c timer.c
  group fwlib
    ./fwlib/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_cortex.c stm32h7xx_hal_exti.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c
