# Keil uVision project LoraSTMac.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32L152RCTxA STMicroelectronics
  pack: Keil.STM32L1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: LoraSTMac
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L152xCA,REGION_CN470
  c misc: --C99
  c include: .\fwlib\CMSIS\Device\ST\STM32L1xx\Include;.\fwlib\STM32L1xx_HAL_Driver\Inc;.\apps;.\apps\common;.\mac;.\peripherals;.\boards;.\radio;.\radio\sx1276;.\system
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  link misc: --diag_suppress=L6329
  group start_up
    ./: startup_stm32l152xc.s
  group apps
    ./apps/: main.c system_stm32l1xx.c stm32l1xx_it.c
    ./apps/common/: NvmCtxMgmt.c
  group mac
    ./mac/region/: Region.c RegionCommon.c RegionCN470.c
    ./mac/: LoRaMac.c LoRaMacAdr.c LoRaMacCommands.c LoRaMacConfirmQueue.c LoRaMacCrypto.c LoRaMacFCntHandler.c LoRaMacParser.c LoRaMacSerializer.c LoRaMacClassB.c
  group peripherals
    ./peripherals/soft-se/: aes.c cmac.c soft-se.c
  group boards
    ./boards/: board.c led-board.c gpio-board.c uart-board.c spi-board.c lpm-board.c rtc-board.c utilities.c delay-board.c sx1276-board.c
  group radio
    ./radio/sx1276/: sx1276.c
  group system
    ./system/: gpio.c fifo.c uart.c delay.c systime.c timer.c
  group fwlib
    ./fwlib/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal.c stm32l1xx_hal_cortex.c stm32l1xx_hal_gpio.c stm32l1xx_hal_pwr.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_rcc.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_rtc.c stm32l1xx_hal_rtc_ex.c stm32l1xx_hal_spi.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_uart.c stm32l1xx_hal_dma.c
software components: CMSIS:CORE 5.0.1
